<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CARRIER</name>
    <file>
      <name>$PROJ_DIR$\API\Src\74.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\Src\hardware_layer_data_process.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\Src\math.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\Src\sample.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\Src\stm32f0308_plc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\Src\stm32f030_peripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\Src\stm32f0xx_it.c</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\CMSIS\Include\core_cm0.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\startup_stm32f030x8.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\Include\stm32f030x8.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\Include\stm32f0xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f0xx.c</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_adc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_cortex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_crc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_dac_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_flash_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_i2c_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_irda.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_msp_template.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_pcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_pcd_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_pwr_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_rcc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_rtc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_smartcard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_smartcard_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_smbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_tim_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_tsc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_uart_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\API\Src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\Src\main_prcess.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\Src\uart.c</name>
    </file>
  </group>
  <group>
    <name>WIRELESS</name>
    <file>
      <name>$PROJ_DIR$\API\wireless\wireless_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\wireless\wireless_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\API\wireless\wireless_hal.c</name>
    </file>
  </group>
</project>


